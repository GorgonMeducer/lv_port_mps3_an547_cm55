# Keil uVision project lv_template.uvprojx, settings and files
target Cortex-M55_FVP (6170000::V6.17::.\Arm Compiler 6.17)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: lv_template
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\platform
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress=6314
  group platform
    ./platform/: led_port.c led_port.h serial.c serial.h platform.c platform.h
  group Documentation
    ./: Abstract.txt
  group application
    ./: main.c
software components: CMSIS Driver:I2C SBCon 1.0.0, CMSIS Driver:MPC 1.0.0, CMSIS Driver:PPC 1.0.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.5.0, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:Audio I2S 1.0.0, Native Driver:GPIO 1.0.0, Native Driver:I2C SBCon 1.0.0, Native Driver:IO 1.0.0, Native Driver:MPC 1.0.0, Native Driver:PPC 1.0.0, Native Driver:SPI 1.0.0, Native Driver:SysCounter 1.0.0, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.0.0, Native Driver:Watch Dog 1.0.0, Utilities:perf_counter:Core 1.8.1, Compiler:I/O:STDOUT 1.2.0, LVGL:lvgl:Essential 8.1.0, LVGL:lvgl:Extra Themes 8.1.0, LVGL:lvgl:Porting 8.1.0
